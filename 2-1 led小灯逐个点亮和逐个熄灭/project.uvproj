# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ptoject.c
    ../3-1 独立按键控制led小灯的状态/: priject.c
  group New Group
    ../3-1 独立按键控制led小灯的状态/: main.c
